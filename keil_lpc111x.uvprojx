# Keil uVision project keil_lpc111x.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: keil_lpc111x
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
